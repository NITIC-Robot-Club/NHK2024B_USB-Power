# Repository NITIC-Robot-Club/NHK2024B_USB-Power

File README.md:

# USB_Power
- 12V入力 5V 6A出力 2系統
	- 系統1: 
		- USB-A	スタッキングコネクタ
	- 系統2: 
		- USB-A スタッキングコネクタ
		- USB-C

## KiCad design USB_power.kicad_pcb

Parts:
C1, C2: 22uF; C_0805_2012Metric
C5, C10: 10uF; C_0805_2012Metric
D1, D2: LED; LED_0603_1608Metric
F1: Fuse; FUSE_3557-2
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J1: PWR_IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J2, J5: USB_A_Stacked; USB_A_CUI_UJ2-ADH-TH_Horizontal_Stacked
J3: Power_check; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
MD1, MD2: OKL-T_6-W12N-C; MURATA_OKL-T-6-W12N-C_0; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C; MOUSER_DESCRIPTION Non-Isolated DC/DC Converters 12Vin .59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
R1, R4, R6, R9: 1k; R_0805_2012Metric
R2, R7: 330R; R_0805_2012Metric
R3, R8: 10R; R_0805_2012Metric
R5, R10: 200R; R_0805_2012Metric
R11, R12, R13, R14: 10k; R_0805_2012Metric
SW1: Switch; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm

Connections:
+5V: C5.1, D1.2 (A), J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), J5.1 (VBUS1), J5.5 (VBUS2), MD1.4 (VOUT), MD1.5 (SENSE), R4.1
+5VP: C10.1, D2.2 (A), J2.1 (VBUS1), J2.5 (VBUS2), MD2.4 (VOUT), MD2.5 (SENSE), R9.1
+BATT: F1.2, J1.2, J3.2
Battery: C1.1, C2.1, F1.1, MD1.2 (VIN), MD2.2 (VIN), R13.1
CTRL: MD1.1 (~ON/OFF_CONTROL), MD2.1 (~ON/OFF_CONTROL), SW1.1 (B)
GND: C1.2, C2.2, C5.2, C10.2, J1.1, J2.4 (GND1), J2.8 (GND2), J3.1, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J5.4 (GND1), J5.8 (GND2), MD1.3 (1_GROUND), MD1.7 (2_GROUND), MD2.3 (1_GROUND), MD2.7 (2_GROUND), R3.2, R5.2, R8.2, R10.2, R11.2, R12.2, R14.2, SW1.2 (C)
unnamed: D1.1 (K), R11.1
unnamed: D2.1 (K), R12.1
unnamed: MD1.6 (TRIM), R1.1
unnamed: MD2.6 (TRIM), R6.1
unnamed: R1.2, R2.1
unnamed: R2.2, R3.1
unnamed: R4.2, R5.1
unnamed: R6.2, R7.1
unnamed: R7.2, R8.1
unnamed: R9.2, R10.1
unnamed: R13.2, R14.1, SW1.3 (A)

Notes on the sheet:
ROUTER/MCU系統
LiDAR/Pi 系統
負荷点付近で接続？

Board: 2 copper layers, 45.1 x 66.0 mm, 33 parts (0 on the bottom side), 17 nets.

## Commit log

2024-06-12 README.mdを追加
2024-06-13 .gitignoreに *.lck を追加
2024-06-13 電源回り諸定数の修正、参照先の追加
2024-06-13 参照先の追加に追記
2024-06-14 gitignore更新、ライブラリテーブル無視
2024-06-14 ライブラリ追加: OKL-T-W12N-C
2024-06-14 スケッチ完成、PCBベタまで完成 あと外形
2024-06-14 名前変更
2024-06-15 USB-Cに変更
2024-06-15 USB-Cにフップリ割り当て
2024-06-15 配線完了
2024-06-15 XT60の向きなおした
2024-06-15 穴あけなど
2024-06-15 5V確認用LED追加
2024-06-15 PCB: 5V確認用LED配置
2024-06-15 USBコネクタ構成変更: stucked_A、A、C
2024-06-16 PCB: フィレット
2024-06-16 配線太さ調整
2024-06-16 ベタ微調整
2024-06-16 穴位置微調整
2024-06-16 シルク調整
2024-06-16 C周り5Vビア追加
2024-06-16 【定期】なぜポリゴンは曲がってしまうのか
2024-06-16 全体位置調整
2024-06-16 初！？PDF作成
2024-06-16 趣味を追加
2024-06-16 趣味を更新
2024-06-16 趣味を配置
2024-06-16 gbrs新規作成、初回zip制作
2024-06-16 USB-C以外パワーベタ解決 Cはあとで
2024-06-17 PCB: パワーベタを細くした
2024-06-17 スケッチ見た目調整
2024-06-17 リネーム: gbrs -> USB_power_gbrs
2024-06-17 加工機用ガーバー出した
2024-06-17 USB-C周りベタ変更、部品配置大幅変更
2024-06-17 PDF更新
2024-06-17 +BATT短縮
2024-06-17 シルク配置微調整
2024-06-17 MD2直下BATTビア調整
2024-06-18 ガーバーをがバっと出す
2024-06-18 ガバーをジプー
2024-06-18 Cのスペース詰めてGNDベタ回り込み
2024-06-18 MD2周り抵抗ゴン詰め、MD1系統スタックコネクタ化計画
2024-06-18 SCH: MD1系統スタックコネクタに変更
2024-06-18 PCB: MD1系統スタックコネクタに変更
2024-06-18 PDF: 更新
2024-06-18 部品配置調整、XT60にMask追加
2024-06-18 MD2系統 5V出力手前ビア追加
2024-06-18 USB-C周りGNDベタ幅改善
2024-06-18 SCH: 不本意にもヒューズを追加
2024-06-18 ヒューズ追加、外形削除
2024-06-18 あなを、かっこよくした！
2024-06-18 穴のシルク調整
2024-06-18 MD1系統GNDベタ改善
2024-06-18 穴クリアランス改善
2024-06-18 実装用CSV追加
2024-06-18 ヘイローサイズアップ
2024-06-18 ヘイロー変更適用、位置変更
2024-06-19 外形フィレット
2024-06-19 ガーバー更新
2024-06-19 zipでポン
2024-06-19 スイッチと分圧抵抗配置
2024-06-19 スイッチ回り配線改善
2024-06-19 DRC実行！！！！！！
2024-06-19 SW1シルク移動
2024-06-19 スイッチ追加版ガーバー出力
2024-06-19 穴のシンボル変更
2024-06-19 がばー更新
2024-06-19 zipまとめ
2024-06-19 GNDベタ全域拡大
2024-06-19 りどみ編集
2024-06-19 ライブラリをlocallibへ移動
2024-06-19 フットプリントもlocallibへ移動（わすれてた)
2024-06-20 がばーして発注
2024-06-30 BOM更新
